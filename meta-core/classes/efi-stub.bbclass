# There is nothing special to do in order to use the efi-stub.
