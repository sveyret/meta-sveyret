# Dummy recipe creating an empty package.

SUMMARY = "A dummy package to be used with kernel EFI_STUB."

LICENSE = "MIT"

ALLOW_EMPTY:${PN} = "1"
